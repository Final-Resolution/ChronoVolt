# Repository Final-Resolution/ChronoVolt

File README.md:

# ChronoVolt

使用8-MD-06INKM制作的VFD时钟，基于ESP32-WROOM

## 项目概述

项目概述是关于项目的一段简短描述，解释该项目是什么以及它的目标和用途。

## 功能特点

列出项目的主要功能和特点，突出该项目的独特之处。

- 特点1：说明特点1的功能和优势。
- 特点2：说明特点2的功能和优势。
- 特点3：说明特点3的功能和优势。

## 安装和使用

提供项目的安装和使用指南，以帮助其他用户快速上手和开始使用该项目。

1. 安装步骤1。
2. 安装步骤2。
3. 使用示例代码或配置文件。

## 硬件设计

如果项目涉及硬件设计，可以提供有关硬件设计的详细信息。

- 原理图：放置原理图文件的链接或说明。
- 电路板布局：放置电路板布局文件的链接或说明。
- 元件清单：列出所使用的主要元件和器件。

## 软件/固件

如果项目涉及软件或固件开发，可以提供有关软件/固件的详细信息。

- 代码库：放置代码库的链接或说明。
- 依赖项：列出所需的主要软件或库的依赖项。

## 贡献

欢迎其他开发者和用户为该项目做出贡献。在贡献部分提供以下信息：

- 贡献方式：说明如何参与该项目的贡献，例如提交问题、提出建议或提交代码。 
- 贡献指南：提供贡献者应遵循的指南和行为准则。
- 开发环境设置：提供如何设置开发环境的说明。

## 许可证

在这个部分指定项目的许可证类型和版权信息。

## 联系方式

提供与项目相关的联系方式，例如邮件地址、社交媒体链接等。

## KiCad design 1.Hardware/ChronoVolt_Control_Rev0.3/ChronoVolt_Control.kicad_pcb

Parts:
C5, C7, C8: 22μF; C_0603_1608Metric
C6: 22pF; C_0603_1608Metric
D5: 1N5819; D_SOD-323
F1: Fuse; Fuse_0805_2012Metric
L1: 2.2μH; L_1008_2520Metric
Q1: CJ2301; TSOT-23
R7: 10K; R_0603_1608Metric
R8: 100K; R_0603_1608Metric
R9: 22K; R_0603_1608Metric
SW1: SW_Push_SPDT; SW_SPDT_PCM12
TP2: TP_3V3; TestPoint_Pad_D1.0mm
U3: SY8089AAAC; SOT-23-5

Connections:
+3V3: C6.1, C7.1, C8.1, L1.2, R8.1, TP2.1; also elsewhere on the board
+5V: C5.1, SW1.3 (C), U3.1 (EN), U3.4 (IN); also elsewhere on the board
+BATT: Q1.3 (D); also elsewhere on the board
GND: C5.2, C7.2, C8.2, R7.2, R9.2, U3.2 (GND); also elsewhere on the board
unnamed: D5.2 (A), F1.2, Q1.1 (G), R7.1
unnamed: D5.1 (K), Q1.2 (S), SW1.2 (B)
unnamed: C6.2, R8.2, R9.1, U3.5 (FB)
unnamed: L1.1, U3.3 (LX)
VBUS: F1.1; also elsewhere on the board

Notes on the sheet:
反馈电阻精度为1%

Parts:
C1: 100nF; C_0603_1608Metric
D1, D2: CESDBLC5V0D3; D_SOD-923
J1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_Palconn_UTC16-G
R1, R2: 5.1K; R_0603_1608Metric
TP1: TP_GND; TestPoint_Pad_D1.0mm

Connections:
GND: C1.2, D1.1 (A1), D2.1 (A1), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), R1.1, R2.1, TP1.1; also elsewhere on the board
unnamed: J1.A5 (CC1), R1.2
unnamed: J1.B5 (CC2), R2.2
USB_D+: D2.2 (A2), J1.A6 (D+), J1.B6 (D+); also elsewhere on the board
USB_D-: D1.2 (A2), J1.A7 (D-), J1.B7 (D-); also elsewhere on the board
VBUS: C1.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS); also elsewhere on the board

Parts:
C29, C30: 100nF; C_0603_1608Metric
D14: 1N4148; D_SOD-323
LS1: Buzzer_MLT-8530_Passive; BUZ-SMD_4P-L8.5-W8.5-TL
Q2: AO3400A; SOT-23
R34: 100R; R_0603_1608Metric
R35: 2K; R_0603_1608Metric

Connections:
+3V3: C29.2, D14.1 (K), LS1.1; also elsewhere on the board
BUZZER: R34.1; also elsewhere on the board
GND: C29.1, C30.2, LS1.3, LS1.4, R35.1; also elsewhere on the board
unnamed 34: D14.2 (A), LS1.2; also elsewhere on the board
unnamed 38: C30.1, R34.2, R35.2; also elsewhere on the board

Parts:
TP3: TP_GND; TestPoint_Pad_D1.0mm
TP4: TP_VBUS; TestPoint_Pad_D1.0mm
TP5: TP_+BATT; TestPoint_Pad_D1.0mm
TP6: TP_BAT; TestPoint_Pad_D1.0mm
TP7: TP_+5V; TestPoint_Pad_D1.0mm
TP8: TP_+3v3; TestPoint_Pad_D1.0mm

Connections:
+3V3: TP8.1; also elsewhere on the board
+5V: TP7.1; also elsewhere on the board
+BATT: TP5.1; also elsewhere on the board
BAT+: TP6.1; also elsewhere on the board
GND: TP3.1; also elsewhere on the board
VBUS: TP4.1; also elsewhere on the board

Parts:
C24: 100nF; C_0603_1608Metric
C33: 0.1μF; C_0603_1608Metric
R16: 4K7; R_0603_1608Metric
R17, R31, R41: 10K; R_0603_1608Metric
R30: LDR_GL5528; R_LDR_5.1x4.3mm_P3.4mm_Vertical
R32, R42: 0R; R_0603_1608Metric
U8: SHT31-DIS; Sensirion_DFN-8-1EP_2.5x2.5mm_P0.5mm_EP1.1x1.7mm

Connections:
+3V3: R30.1, R42.1; also elsewhere on the board
GND: C24.2, C33.2, R31.2, R41.1, U8.7 (R), U8.8 (VSS), U8.9 (VSS); also elsewhere on the board
I2C_SCL: U8.4 (SCL); also elsewhere on the board
I2C_SDA: U8.1 (SDA); also elsewhere on the board
LDR_ADC: R32.1; also elsewhere on the board
unnamed: C24.1, R30.2, R31.1, R32.2
unnamed: R17.2, R41.2, U8.2 (ADDR)
unnamed: C33.1, R16.1, R17.1, R42.2, U8.5 (VDD)
unnamed: R16.2, U8.6 (~RESET)

Notes on the sheet:
IIC Address -------------------- ADDR:L |Address 0X44 ADDR:H |Address 0X45
LDR

Parts:
C9, C12: 100nF; C_0603_1608Metric
C10: 1uF; C_0603_1608Metric
C11: 22uF; C_0603_1608Metric
R10, R11, R14: 10K; R_0603_1608Metric
R12, R13: 4.7K; R_0603_1608Metric
SW2: EN_KEY; Panasonic_EVQPUL_EVQPUC
SW3: BOOT_KEY; Panasonic_EVQPUL_EVQPUC
U4: ESP32-WROOM-32D

Connections:
3V3_EN: U4.26 (IO4); also elsewhere on the board
+3V3: C10.2, C11.1, C12.1, R10.1, R12.2, R13.2, R14.1, U4.2 (VDD); also elsewhere on the board
ADC_VBAT: U4.9 (IO33); also elsewhere on the board
BOOT: R14.2, SW3.2, U4.25 (IO0); also elsewhere on the board
BUZZER: U4.13 (IO14); also elsewhere on the board
DOWN_KEY: U4.28 (IO17); also elsewhere on the board
EF_EN: U4.14 (IO12); also elsewhere on the board
ENTER_KEY: U4.27 (IO16); also elsewhere on the board
GND: C9.1, C10.1, C11.2, C12.2, R11.1, SW2.1, SW3.1, U4.1 (GND), U4.15 (GND), U4.38 (GND), U4.39 (GND); also elsewhere on the board
HV_EN: U4.16 (IO13); also elsewhere on the board
I2C_SCL: R13.1, U4.36 (IO22); also elsewhere on the board
I2C_SDA: R12.1, U4.33 (IO21); also elsewhere on the board
LDR_ADC: U4.8 (IO32); also elsewhere on the board
MODE_SWITCH0: U4.11 (IO26); also elsewhere on the board
MODE_SWITCH1: U4.12 (IO27); also elsewhere on the board
unnamed: R11.2, U4.24 (IO2)
RGB_DIN: U4.10 (IO25); also elsewhere on the board
RTC_INT: U4.6 (IO34); also elsewhere on the board
UART_RXD: U4.35 (TXD0/IO1); also elsewhere on the board
UART_TXD: U4.34 (RXD0/IO3); also elsewhere on the board
UP_KEY: U4.23 (IO15); also elsewhere on the board
VFD_CS: U4.29 (IO5); also elsewhere on the board
VFD_RES: U4.31 (IO19); also elsewhere on the board
VFD_SCLK: U4.30 (IO18); also elsewhere on the board
VFD_SDIN: U4.37 (IO23); also elsewhere on the board
~EN: C9.2, R10.2, SW2.2, U4.3 (EN); also elsewhere on the board

Notes on the sheet:
I2C 使用的GPIO为开漏结构，要求外部有电阻上拉， 电阻和总线电容产生了一个 RC 延时效应， 电容越大信号的边沿就越缓，有可能带来信号质量风险。
GPIO2需连接10K下拉电阻, 以使ESP32能正常下载程序

Parts:
C25, C26, C27, C28: 100nF; C_0603_1608Metric
D10, D11, D12, D13: WS2812B; LED-SMD_4P-L2.0-W1.8_CY-0807
R33: 470R; R_0603_1608Metric

Connections:
+5V: C25.1, C26.1, C27.1, C28.1, D10.1 (VDD), D11.1 (VDD), D12.1 (VDD), D13.1 (VDD); also elsewhere on the board
GND: C25.2, C26.2, C27.2, C28.2, D10.3 (VSS), D11.3 (VSS), D12.3 (VSS), D13.3 (VSS); also elsewhere on the board
unnamed: D10.4 (DIN), R33.2
unnamed: D10.2 (DOUT), D11.4 (DIN)
unnamed: D11.2 (DOUT), D12.4 (DIN)
unnamed: D12.2 (DOUT), D13.4 (DIN)
RGB_DIN: R33.1; also elsewhere on the board

Parts:
R36, R37, R38, R39, R40: 10K; R_0603_1608Metric
SW5: UP_KEY; SW_SPST_TL3342
SW6: MODE_SWITCH; SW_DIP_SPSTx02_Slide_6.7x6.64mm_W8.61mm_P2.54mm_LowProfile
SW7: ENTER_KEY; SW_SPST_TL3342
SW8: DOWN_KEY; SW_SPST_TL3342

Connections:
+3V3: R37.2, R38.2, SW5.2, SW7.2, SW8.2; also elsewhere on the board
DOWN_KEY: R40.1, SW8.1; also elsewhere on the board
ENTER_KEY: R39.1, SW7.1; also elsewhere on the board
GND: R36.2, R39.2, R40.2, SW6.3, SW6.4; also elsewhere on the board
MODE_SWITCH0: R37.1, SW6.1; also elsewhere on the board
MODE_SWITCH1: R38.1, SW6.2; also elsewhere on the board
UP_KEY: R36.1, SW5.1; also elsewhere on the board

Schematic: UART_CH340C.kicad_sch, ChronoVolt_Control

Parts:
C2, C3, C4: 100nF; C_0603_1608Metric
D3: TX_LED; LED_0603_1608Metric
D4: RX_LED; LED_0603_1608Metric
R3, R4, R5, R6: 470R; R_0603_1608Metric
U1: DDC114TU-7-F; SOT-363_SC-70-6
U2: CH340C; SOIC-16_3.9x9.9mm_P1.27mm

Connections:
+3V3: C2.2, C3.2, C4.2, R5.1, R6.1, U2.4 (V3), U2.16 (VCC); also elsewhere on the board
/UART_CH340C/DTR: U1.2 (B1), U1.4 (E2), U2.13 (~DTR)
/UART_CH340C/RTS: U1.1 (E1), U1.5 (B2), U2.14 (~RTS)
BOOT: U1.3 (C2); also elsewhere on the board
GND: C2.1, C3.1, C4.1, U2.1 (GND); also elsewhere on the board
unnamed: D3.2 (A), R5.2
unnamed: D4.2 (A), R6.2
unnamed: R4.1, U2.3 (RXD)
unnamed: R3.1, U2.2 (TXD)
UART_RXD: D4.1 (K), R4.2; also elsewhere on the board
UART_TXD: D3.1 (K), R3.2; also elsewhere on the board
USB_D+: U2.5 (UD+); also elsewhere on the board
USB_D-: U2.6 (UD-); also elsewhere on the board
~EN: U1.6 (C1); also elsewhere on the board

Notes on the sheet:
The crystal oscillator circuit is soldered only when CH340G is used. It is not necessary when using CH340C.

Schematic: CHARGE_IP5306.kicad_sch, ChronoVolt_Control

Parts:
BT1: Battery; CONN-SMD_ZH1.5-2P-WT
C16, C17, C18, C19: 10uF; C_0603_1608Metric
C20, C21: 100nF; C_0603_1608Metric
D6: 25%; LED_0603_1608Metric
D7: 50%; LED_0603_1608Metric
D8: 75%; LED_0603_1608Metric
D9: 100%; LED_0603_1608Metric
L2: 1uH; L_1008_2520Metric
R19, R24, R27: 0R; R_0603_1608Metric
R20, R21: 4.7K; R_0603_1608Metric
R22: 20R; R_0603_1608Metric
R23: 0.5R; R_0603_1608Metric
R25, R26: 470K; R_0603_1608Metric
SW4: Power_SW; Panasonic_EVQPUL_EVQPUC
U6: IP5306; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.29x3mm_ThermalVias

Connections:
+BATT: C17.1, C18.1, U6.8 (VOUT); also elsewhere on the board
ADC_VBAT: C21.1, R27.1; also elsewhere on the board
BAT+: BT1.1 (+), C20.1, L2.2, R23.2, R24.2; also elsewhere on the board
GND: BT1.2 (-), C16.1, C17.2, C18.2, C19.2, C20.2, C21.2, R26.1, SW4.2, U6.9 (GND); also elsewhere on the board
unnamed: D6.2 (A), D7.1 (K), R20.1
unnamed: D6.1 (K), D7.2 (A), D8.1 (K), D9.2 (A), U6.4 (LED3)
unnamed: D8.2 (A), D9.1 (K), R21.1
unnamed: R22.1, SW4.1
unnamed: R24.1, R25.2
unnamed: R25.1, R26.2, R27.2
unnamed: C19.1, R23.1, U6.6 (BAT)
unnamed: R22.2, U6.5 (KEY)
unnamed: R20.2, U6.2 (LED1)
unnamed: R21.2, U6.3 (LED2)
unnamed: L2.1, U6.7 (SW)
unnamed: C16.2, R19.2, U6.1 (VIN)
VBUS: R19.1; also elsewhere on the board

Schematic: CON_PIN.kicad_sch, ChronoVolt_Control

Parts:
J2: Conn_01x09_Pin; Con_Pin_1x09_3mm

Connections:
3V3_EN: J2.8; also elsewhere on the board
+5V: J2.9; also elsewhere on the board
EF_EN: J2.6; also elsewhere on the board
GND: J2.1; also elsewhere on the board
HV_EN: J2.7; also elsewhere on the board
VFD_CS: J2.4; also elsewhere on the board
VFD_RES: J2.5; also elsewhere on the board
VFD_SCLK: J2.3; also elsewhere on the board
VFD_SDIN: J2.2; also elsewhere on the board

Schematic: HOLE.kicad_sch, ChronoVolt_Control

Parts:
H1, H2, H3, H4: MountingHole_Pad; MountingHole_2.5mm_Pad_Via

Connections:
GND: H1.1, H2.1, H3.1, H4.1; also elsewhere on the board

Schematic: RTC_PCF8563.kicad_sch, ChronoVolt_Control

Parts:
BT2: Battery_Cell; BS-1220-2
C13, C14: 9pF; C_0603_1608Metric
C15, C31, C32: 0.1μF; C_0603_1608Metric
D15, D16: 1N4148WS; D_SOD-323
R15, R18: 10K; R_0603_1608Metric
U5: BM8563EMA; SOIC-8_3.9x4.9mm_P1.27mm
Y1: 32.768KHz; Crystal_SMD_3215-2Pin_3.2x1.5mm

Connections:
32KHZ: R18.2, U5.7 (CLKO)
+3V3: D15.2 (A), R15.1, R18.1; also elsewhere on the board
GND: BT2.2 (-), C13.1, C14.1, C15.1, C31.2, C32.2, U5.4 (VSS); also elsewhere on the board
I2C_SCL: U5.6 (SCL); also elsewhere on the board
I2C_SDA: U5.5 (SDA); also elsewhere on the board
unnamed: BT2.1 (+), C31.1, D16.2 (A)
unnamed: C15.2, C32.1, D15.1 (K), D16.1 (K), U5.8 (VDD)
unnamed: C13.2, U5.1 (OSCI), Y1.1
unnamed: C14.2, U5.2 (OSCO), Y1.2
RTC_INT: R15.2, U5.3 (~INT); also elsewhere on the board

Board: 2 copper layers, 98.0 x 52.0 mm, 121 parts (2 on the bottom side), 68 nets.

Other parts of the board:
Q3: AO3400A; SOT-23

Their connections:
GND: Q3.2 (S); also elsewhere on the board
unnamed 34: Q3.3 (D); also elsewhere on the board
unnamed 38: Q3.1 (G); also elsewhere on the board

File 1.Hardware/ChronoVolt_Control_Rev0.3/production/ChronoVolt_Control_2024-06-05_14-16-48/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
BT1,CONN-SMD_ZH1.5-2P-WT,1,Battery,
BT2,BS-1220-2,1,Battery_Cell,
"C1, C12, C2, C20, C21, C24, C25, C26, C27, C28, C29, C3, C30, C4, C9",0603,15,100nF,
C10,0603,1,1uF,
C11,0603,1,22uF,
"C13, C14",0603,2,9pF,
"C15, C32, C33",0603,3,0.1μF,
"C16, C17, C18, C19",0603,4,10uF,
"C5, C7, C8",0603,3,22μF,
C6,0603,1,22pF,
"D10, D11, D12, D13",LED-SMD_4P-L2.0-W1.8_CY-0807,4,WS2812B,
D14,D_SOD-323,1,1N4148,
"D15, D16",D_SOD-323,2,1N4148WS,
D3,0603,1,TX_LED,
D4,0603,1,RX_LED,
D5,D_SOD-323,1,1N5819,
D6,0603,1,25%,
D7,0603,1,50%,
D8,0603,1,75%,
D9,0603,1,100%,
F1,0805,1,Fuse,
"H1, H2, H3, H4",MountingHole_2.5mm_Pad_Via,4,MountingHole_Pad,
J1,USB_C_Receptacle_Palconn_UTC16-G,1,USB_C_Receptacle_USB2.0,
J2,Con_Pin_1x09_3mm,1,Conn_01x09_Pin,
L1,1008,1,2.2μH,
L2,1008,1,1uH,
LS1,BUZ-SMD_4P-L8.5-W8.5-TL,1,Buzzer_MLT-8530_Passive,
Q1,TSOT-23,1,CJ2301,
Q3,SOT-23,1,AO3400A,
"R1, R2",0603,2,5.1K,
"R10, R11, R14, R15, R31, R36, R37, R38, R39, R40, R41, R7",0603,12,10K,
"R12, R13, R20, R21",0603,4,4.7K,
R16,0603,1,4K7,
"R19, R24, R27, R32, R42",0603,5,0R,
R23,0603,1,0.5R,
"R25, R26",0603,2,470K,
"R3, R33, R4, R5, R6",0603,5,470R,
R30,R_LDR_5.1x4.3mm_P3.4mm_Vertical,1,LDR_GL5528,
R34,0603,1,100R,
R35,0603,1,2K,
R8,0603,1,100K,
R9,0603,1,22K,
SW1,SW_SPDT_PCM12,1,SW_Push_SPDT,
SW2,Panasonic_EVQPUL_EVQPUC,1,EN_KEY,
SW3,Panasonic_EVQPUL_EVQPUC,1,BOOT_KEY,
SW5,SW_SPST_TL3342,1,UP_KEY,
SW6,SW_DIP_SPSTx02_Slide_6.7x6.64mm_W8.61mm_P2.54mm_LowProfile,1,MODE_SWITCH,
SW7,SW_SPST_TL3342,1,ENTER_KEY,
SW8,SW_SPST_TL3342,1,DOWN_KEY,
"TP1, TP3",TestPoint_Pad_D1.0mm,2,TP_GND,
TP2,TestPoint_Pad_D1.0mm,1,TP_3V3,
TP4,TestPoint_Pad_D1.0mm,1,TP_VBUS,
TP5,TestPoint_Pad_D1.0mm,1,TP_+BATT,
TP6,TestPoint_Pad_D1.0mm,1,TP_BAT,
TP7,TestPoint_Pad_D1.0mm,1,TP_+5V,
TP8,TestPoint_Pad_D1.0mm,1,TP_+3v3,
U1,SOT-363_SC-70-6,1,DDC114TU-7-F,
U2,SOIC-16_3.9x9.9mm_P1.27mm,1,CH340C,
U3,SOT-23-5,1,SY8089AAAC,
U4,ESP32-WROOM-32D,1,ESP32-WROOM-32D,
U5,SOIC-8_3.9x4.9mm_P1.27mm,1,BM8563EMA,
U6,SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.29x3mm_ThermalVias,1,IP5306,
U8,Sensirion_DFN-8-1EP_2.5x2.5mm_P0.5mm_EP1.1x1.7mm,1,SHT31-DIS,
Y1,Crystal_SMD_3215-2Pin_3.2x1.5mm,1,32.768KHz,

## KiCad design 1.Hardware/ChronoVolt_Display/ChronoVolt_Display.kicad_pcb

Parts:
J1: Conn_01x09_Pin; Con_Pin_1x09_3mm

Connections:
3V3_EN: J1.8; also elsewhere on the board
+5V: J1.9; also elsewhere on the board
EF_EN: J1.6; also elsewhere on the board
GND: J1.1; also elsewhere on the board
HV_EN: J1.7; also elsewhere on the board
VFD_CS: J1.4; also elsewhere on the board
VFD_RES: J1.5; also elsewhere on the board
VFD_SCLK: J1.3; also elsewhere on the board
VFD_SDIN: J1.2; also elsewhere on the board

Parts:
TP1: TP_GND; TestPoint_Pad_D1.0mm
TP2: TP_+5V; TestPoint_Pad_D1.0mm
TP3: TP_+3v3; TestPoint_Pad_D1.0mm
TP4: TP_+24V; TestPoint_Pad_D1.0mm

Connections:
+3V3: TP3.1; also elsewhere on the board
+5V: TP2.1; also elsewhere on the board
+24V: TP4.1; also elsewhere on the board
GND: TP1.1; also elsewhere on the board

Parts:
C1: 0.1uF; C_0603_1608Metric
C2: 47uF; C_0603_1608Metric
D1: 1N5819WS; D_SOD-323
Q1: CJ2301; TSOT-23
R1, R2: 3R; R_0603_1608Metric
R3: 39K; R_0603_1608Metric
R4: 180R; R_0603_1608Metric
R5: 10K; R_0603_1608Metric
VFD1: Futaba_8-MD-06INKM; FUTABA_8-MD-06INKM

Connections:
+3V3: C1.1, C2.1, Q1.3 (D), R3.2, R5.1, VFD1.27 (VDD); also elsewhere on the board
+24V: VFD1.29 (VH); also elsewhere on the board
/VFD_8-MD-06INKM/F+: Q1.2 (S), VFD1.34 (F+), VFD1.35 (F+)
/VFD_8-MD-06INKM/F-: R1.1, R2.1, VFD1.1 (F-), VFD1.2 (F-)
EF_EN: R4.2; also elsewhere on the board
GND: C1.2, C2.2, D1.1 (K), VFD1.10 (TSB), VFD1.31 (PGND), VFD1.32 (LGND); also elsewhere on the board
unnamed: D1.2 (A), R1.2, R2.2
unnamed: Q1.1 (G), R4.1, R5.2
unnamed: R3.1, VFD1.24 (OSC)
VFD_CS: VFD1.20 (CS); also elsewhere on the board
VFD_RES: VFD1.22 (RES); also elsewhere on the board
VFD_SCLK: VFD1.17 (SCLK); also elsewhere on the board
VFD_SDIN: VFD1.15 (SDIN); also elsewhere on the board

Parts:
C3: 22μF; C_0603_1608Metric
C4: 22pF/50V; C_0603_1608Metric
C5: 0.1μF/50V; C_0603_1608Metric
C6: 4.7μF/50V; C_0603_1608Metric
D2: 1N5819WS; D_SOD-323
L1: 10uH; L_1008_2520Metric
R6, R7: 10K; R_0603_1608Metric
R8: 300K; R_0603_1608Metric
R9: 16K; R_0603_1608Metric
U1: SGM6601YTN5G/TR; TSOT-23-5

Connections:
+5V: C3.1, L1.1, R6.1, U1.5 (VIN); also elsewhere on the board
+24V: C4.1, C5.1, C6.1, D2.1 (K), R8.1; also elsewhere on the board
GND: C3.2, C5.2, C6.2, R9.2, U1.2 (GND); also elsewhere on the board
HV_EN: R7.2; also elsewhere on the board
unnamed: D2.2 (A), L1.2, U1.1 (SW)
unnamed: R6.2, R7.1, U1.4 (EN)
unnamed: C4.2, R8.2, R9.1, U1.3 (FB)

Notes on the sheet:
反馈电阻精度为1%

Parts:
C7, C9, C10: 22μF; C_0603_1608Metric
C8: 22pF; C_0603_1608Metric
L2: 2.2μH; L_1008_2520Metric
R10, R13: 10K; R_0603_1608Metric
R11: 100K; R_0603_1608Metric
R12: 22K; R_0603_1608Metric
U2: SY8089AAAC; SOT-23-5

Connections:
3V3_EN: R13.2; also elsewhere on the board
+3V3: C8.1, C9.1, C10.1, L2.2, R11.1; also elsewhere on the board
+5V: C7.1, R10.1, U2.4 (IN); also elsewhere on the board
GND: C7.2, C9.2, C10.2, R12.2, U2.2 (GND); also elsewhere on the board
unnamed: R10.2, R13.1, U2.1 (EN)
unnamed: C8.2, R11.2, R12.1, U2.5 (FB)
unnamed: L2.1, U2.3 (LX)

Notes on the sheet:
反馈电阻精度为1%

Board: 2 copper layers, 84.0 x 22.0 mm, 36 parts (34 on the bottom side), 22 nets.

File 1.Hardware/ChronoVolt_Display/production/ChronoVolt_Display_2023-12-27_15-01-14/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
C1,0603,1,0.1uF,
"C10, C3, C7, C9",0603,4,22μF,
C2,0603,1,47uF,
C4,0603,1,22pF/50V,
C5,0603,1,0.1μF/50V,
C6,0603,1,4.7μF/50V,
C8,0603,1,22pF,
"D1, D2",D_SOD-323,2,1N5819WS,
J1,Con_Pin_1x09_3mm,1,Conn_01x09_Pin,
L1,1008,1,10uH,
L2,1008,1,2.2μH,
Q1,TSOT-23,1,CJ2301,
"R1, R2",0603,2,3R,
"R10, R13, R5, R6, R7",0603,5,10K,
R11,0603,1,100K,
R12,0603,1,22K,
R3,0603,1,39K,
R4,0603,1,180R,
R8,0603,1,300K,
R9,0603,1,16K,
TP1,TestPoint_Pad_D1.0mm,1,TP_GND,
TP2,TestPoint_Pad_D1.0mm,1,TP_+5V,
TP3,TestPoint_Pad_D1.0mm,1,TP_+3v3,
TP4,TestPoint_Pad_D1.0mm,1,TP_+24V,
U1,TSOT-23-5,1,SGM6601YTN5G/TR,
U2,SOT-23-5,1,SY8089AAAC,
VFD1,FUTABA_8-MD-06INKM,1,Futaba_8-MD-06INKM,
