# Keil uVision project template.uvproj, settings and files
target template (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: output +hex
  AfterMake: ..\tools\hex2bin.exe  ..\output\@L.hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  group Startup
    ../source/n76e003/startup/: STARTUP.A51
  group src
    ../source/user/: main.c initial.c
    ../source/devices/: font_seg13.c vfd_8md06inkm.c
    ../source/common/: common.c
    ../source/n76e003/: clock.c sfr_macro.c
  group inc
    ../source/n76e003/: N76E003.h
    ../source/user/: config.h initial.h version.h
    ../source/common/: common.h stdint.h
    ../source/devices/: vfd_8md06inkm.h
